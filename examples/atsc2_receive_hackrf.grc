<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>atsc2_receive</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amp</value></param>
<param><key>comment</key><value>0 [off] or 14 [on]</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>195e6</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>value</key><value>-90</value></param>
<param><key>gui_hint</key><value>3,0,1,5</value></param>
<param><key>label</key><value>Low dB Display Cutoff</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hw_sample_rate</value></param>
<param><key>comment</key><value>rtl works best at 2.4 Msps
HackRF and Airspy work best at 10 MSPS</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lna_gain</value></param>
<param><key>comment</key><value>Airspy: 0-21</value></param>
<param><key>value</key><value>14</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>processing_rate</value></param>
<param><key>value</key><value>6.25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>radio_freq</value></param>
<param><key>value</key><value>center_freq+tuning_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuning_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vga_gain</value></param>
<param><key>comment</key><value>RX: 0-62 in 2 dB steps
TX: N/A</value></param>
<param><key>value</key><value>18</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>reference</key><value>4.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>atsc2_stream_server</key>
<param><key>id</key><value>atsc2_stream_server_0</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/atsc.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>correctiq_correctiq</key>
<param><key>id</key><value>correctiq_correctiq_0</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>4096</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dtv_atsc_deinterleaver</key>
<param><key>id</key><value>dtv_atsc_deinterleaver_0</value></param>
</block>
<block>
<key>dtv_atsc_depad</key>
<param><key>id</key><value>dtv_atsc_depad_0</value></param>
</block>
<block>
<key>dtv_atsc_derandomizer</key>
<param><key>id</key><value>dtv_atsc_derandomizer_0</value></param>
</block>
<block>
<key>dtv_atsc_equalizer</key>
<param><key>id</key><value>dtv_atsc_equalizer_0</value></param>
</block>
<block>
<key>dtv_atsc_fpll</key>
<param><key>id</key><value>dtv_atsc_fpll_0</value></param>
<param><key>rate</key><value>11.8385e6</value></param>
</block>
<block>
<key>dtv_atsc_fs_checker</key>
<param><key>id</key><value>dtv_atsc_fs_checker_0</value></param>
</block>
<block>
<key>dtv_atsc_rs_decoder</key>
<param><key>id</key><value>dtv_atsc_rs_decoder_0</value></param>
</block>
<block>
<key>dtv_atsc_rx_filter</key>
<param><key>id</key><value>dtv_atsc_rx_filter_0</value></param>
<param><key>comment</key><value>Original Block was in Python</value></param>
<param><key>rate</key><value>processing_rate</value></param>
<param><key>sps</key><value>1.1</value></param>
</block>
<block>
<key>dtv_atsc_sync</key>
<param><key>id</key><value>dtv_atsc_sync_0</value></param>
<param><key>rate</key><value>11.8385e6</value></param>
</block>
<block>
<key>dtv_atsc_viterbi_decoder</key>
<param><key>id</key><value>dtv_atsc_viterbi_decoder_0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>vga_gain</value></param>
<param><key>freq0</key><value>radio_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>lna_gain</value></param>
<param><key>gain0</key><value>amp</value></param>
<param><key>comment</key><value>HackRF Config</value></param>
<param><key>args</key><value>hackrf</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hw_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>hw_sample_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,2,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>freq_min</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_probe_rate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>dtv_atsc_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>correctiq_correctiq_0</source_block_id><sink_block_id>dtv_atsc_rx_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_correctiq_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_deinterleaver_0</source_block_id><sink_block_id>dtv_atsc_rs_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>atsc2_stream_server_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_depad_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_derandomizer_0</source_block_id><sink_block_id>dtv_atsc_depad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_equalizer_0</source_block_id><sink_block_id>dtv_atsc_viterbi_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_fpll_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_fs_checker_0</source_block_id><sink_block_id>dtv_atsc_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rs_decoder_0</source_block_id><sink_block_id>dtv_atsc_derandomizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_rx_filter_0</source_block_id><sink_block_id>dtv_atsc_fpll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_sync_0</source_block_id><sink_block_id>dtv_atsc_fs_checker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_atsc_viterbi_decoder_0</source_block_id><sink_block_id>dtv_atsc_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>correctiq_correctiq_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
