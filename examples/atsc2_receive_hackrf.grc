options:
  parameters:
    generate_options: qt_gui
    id: atsc2_receive
    output_language: python
  states: {}

blocks:
- name: amp
  id: variable
  parameters:
    comment: 0 [off] or 14 [on]
    value: '0'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,1
    label: Center Frequency
    type: real
    value: 195e6
  states: {}
- name: freq_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,5
    label: Low dB Display Cutoff
    start: '-140'
    step: '1'
    stop: '70'
    value: '-90'
  states: {}
- name: hw_sample_rate
  id: variable
  parameters:
    comment: |-
      rtl works best at 2.4 Msps
      HackRF and Airspy work best at 10 MSPS
    value: 10e6
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    comment: 'Airspy: 0-21'
    gui_hint: 0,3,1,1
    label: LNA Gain
    start: '0'
    step: '1'
    stop: '21'
    value: '14'
  states: {}
- name: processing_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: radio_freq
  id: variable
  parameters:
    value: center_freq+tuning_offset
  states: {}
- name: tuning_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: vga_gain
  id: variable
  parameters:
    comment: |-
      RX: 0-62 in 2 dB steps
      TX: N/A
    value: '18'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '4.0'
    type: float
  states: {}
- name: atsc2_stream_server_0
  id: atsc2_stream_server
  parameters:
    port: '8080'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/atsc.ts
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {state: disabled}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {state: disabled}
- name: correctiq_correctiq_0
  id: correctiq_correctiq
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: dtv_atsc_deinterleaver_0
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: dtv_atsc_depad_0
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: dtv_atsc_derandomizer_0
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: dtv_atsc_equalizer_0
  id: dtv_atsc_equalizer
  parameters: {}
  states: {}
- name: dtv_atsc_fpll_0
  id: dtv_atsc_fpll
  parameters:
    rate: 11.8385e6
  states: {}
- name: dtv_atsc_fs_checker_0
  id: dtv_atsc_fs_checker
  parameters: {}
  states: {}
- name: dtv_atsc_rs_decoder_0
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: dtv_atsc_rx_filter_0
  id: dtv_atsc_rx_filter
  parameters:
    comment: Original Block was in Python
    rate: processing_rate
    sps: '1.1'
  states: {}
- name: dtv_atsc_sync_0
  id: dtv_atsc_sync
  parameters:
    rate: 11.8385e6
  states: {}
- name: dtv_atsc_viterbi_decoder_0
  id: dtv_atsc_viterbi_decoder
  parameters: {}
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: vga_gain
    comment: HackRF Config
    freq0: radio_freq
    gain0: amp
    gain_mode0: 'False'
    if_gain0: lna_gain
    sample_rate: hw_sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: hw_sample_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,2,5
    showports: 'True'
    type: complex
    ymax: '-10'
    ymin: freq_min
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_probe_rate_0_0, '0']
- [analog_agc_xx_0, '0', dtv_atsc_sync_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0_0, print]
- [correctiq_correctiq_0, '0', dtv_atsc_rx_filter_0, '0']
- [correctiq_correctiq_0, '0', qtgui_freq_sink_x_0_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dtv_atsc_deinterleaver_0, '0', dtv_atsc_rs_decoder_0, '0']
- [dtv_atsc_deinterleaver_0, '1', dtv_atsc_rs_decoder_0, '1']
- [dtv_atsc_depad_0, '0', atsc2_stream_server_0, '0']
- [dtv_atsc_depad_0, '0', blocks_file_sink_1, '0']
- [dtv_atsc_depad_0, '0', blocks_null_sink_0, '0']
- [dtv_atsc_depad_0, '0', blocks_probe_rate_0, '0']
- [dtv_atsc_derandomizer_0, '0', dtv_atsc_depad_0, '0']
- [dtv_atsc_equalizer_0, '0', dtv_atsc_viterbi_decoder_0, '0']
- [dtv_atsc_equalizer_0, '1', dtv_atsc_viterbi_decoder_0, '1']
- [dtv_atsc_fpll_0, '0', dc_blocker_xx_0, '0']
- [dtv_atsc_fs_checker_0, '0', dtv_atsc_equalizer_0, '0']
- [dtv_atsc_fs_checker_0, '1', dtv_atsc_equalizer_0, '1']
- [dtv_atsc_rs_decoder_0, '0', dtv_atsc_derandomizer_0, '0']
- [dtv_atsc_rs_decoder_0, '1', dtv_atsc_derandomizer_0, '1']
- [dtv_atsc_rx_filter_0, '0', dtv_atsc_fpll_0, '0']
- [dtv_atsc_sync_0, '0', dtv_atsc_fs_checker_0, '0']
- [dtv_atsc_viterbi_decoder_0, '0', dtv_atsc_deinterleaver_0, '0']
- [dtv_atsc_viterbi_decoder_0, '1', dtv_atsc_deinterleaver_0, '1']
- [osmosdr_source_0_0, '0', correctiq_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
